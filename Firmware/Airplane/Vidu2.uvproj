# Keil uVision project Vidu2.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Vidu2
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F40_41xxx, HSE_VALUE=8000000
  c include: ..\Airplane;.\Include;..\IMU_GPS;..\STM32F4xx_StdPeriph_Driver\inc;..\STM32F4xx_StdPeriph_Driver\src;.\Source;..\PID;..\Control;..\PWM;..\GPIO;..\Stanley;.\Include;..\FSMC;..\RF;..\UTM
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Airplane
    ./: startup_stm32f40_41xxx.s
    ./Source/: stm32f4xx_it.c system_stm32f4xx.c main.c
    ./Include/: include.h define.h
  group STM32F4xx
    ../STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_dma.c stm32f4xx_tim.c stm32f4xx_fsmc.c
  group IMU_GPS
    ../IMU_GPS/: IMU_GPS.c
  group PWM
    ../PWM/: PWM.c
  group PID
    ../PID/: PID.c
  group Control
    ../Control/: Control.c
  group Stanley
    ../Stanley/: Stanley.c
  group GPIO
    ../GPIO/: GPIO.c
  group FSMC
    ../FSMC/: FSMC.c
  group RF
    ../RF/: RF.c
  group UTM
    ../UTM/: UTM.c
